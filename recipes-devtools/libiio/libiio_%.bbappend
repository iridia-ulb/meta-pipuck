EXTRA_OECMAKE_append = " -DLOG_LEVEL=Error"
PACKAGECONFIG_append = " libiio-python3"
